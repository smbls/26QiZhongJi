# Keil uVision project STM32_UART_CMD.uvprojx, settings and files
target STM32_PUL_WHILE (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\APP;..\BSP;..\CMSIS;..\LIB\STM32F10x_StdPeriph_Lib_V3.5.0\inc;..\DRIVERS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../APP/: main.c stm32f10x_conf.h stm32f10x_it.c
  group BSP
    ../BSP/: Emm_V5.c Emm_V5.h usart.c usart.h board.c board.h
  group CMSIS
    ../CMSIS/: core_cm3.c startup_stm32f10x_hd.s system_stm32f10x.c
  group DRIVERS
    ../DRIVERS/: fifo.c fifo.h delay.c delay.h button.c button.h
  group STM32F10x_StdPeriph_Lib_V3.5.0
    ../LIB/STM32F10x_StdPeriph_Lib_V3.5.0/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_tim.c
    ../LIB/STM32F10x_StdPeriph_Lib_V3.5.0/inc/: stm32f10x_adc.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_rcc.h stm32f10x_spi.h stm32f10x_tim.h
